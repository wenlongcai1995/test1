# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\TIMER;..\HARDWARE\GPIO;..\HARDWARE\TIMER;..\HARDWARE\Forward;..\HARDWARE\HandShake;..\HARDWARE\FoucsIn;..\HARDWARE\FoucsOut;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\Back
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/Forward/: Forward.c
    ../HARDWARE/HandShake/: HandShake.c
    ../HARDWARE/FoucsIn/: FoucsIn.c
    ../HARDWARE/FoucsOut/: FoucsOut.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Back/: Back.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c
